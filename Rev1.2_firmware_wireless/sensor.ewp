# IAR project sensor.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F5528 MSP430F5528
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5528.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ./: adc.c adc.h msprf24.h msprf24_sensor.c nRF24L01.h nrf_userconfig_sensor.h sensor_main.c
