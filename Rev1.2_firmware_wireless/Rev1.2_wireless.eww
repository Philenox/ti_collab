<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\DCO_test.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\feedback.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\sensor.ewp</path>
  </project>
  <batchBuild/>
</workspace>


