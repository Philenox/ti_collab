<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\data_collar.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\sensor_hat.ewp</path>
  </project>
  <batchBuild/>
</workspace>


